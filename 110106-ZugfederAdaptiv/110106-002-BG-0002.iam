# Autodesk Inventor assembly: 110106-002-BG-0002
## iProperties
Created: 2011-01
Part Number: 110106-002-BG-0002
Document SubType Name: Assembly
Designer: Schulung
Author: Schulung
